# IAR project libopenthread_platform_utils_mtd_CC1352P_4_LAUNCHXL_tirtos_iar.ewp, settings and files
configuration OptimizeSize (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  group (top)
    ./: libopenthread_platform_utils_mtd_CC1352P_4_LAUNCHXL_tirtos_iar.ipcf
