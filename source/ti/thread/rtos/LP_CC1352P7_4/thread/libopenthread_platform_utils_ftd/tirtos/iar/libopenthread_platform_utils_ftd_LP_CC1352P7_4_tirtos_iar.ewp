# IAR project libopenthread_platform_utils_ftd_LP_CC1352P7_4_tirtos_iar.ewp, settings and files
configuration OptimizeSize (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  group (top)
    ./: libopenthread_platform_utils_ftd_LP_CC1352P7_4_tirtos_iar.ipcf
